# Keil uVision project 110r-m4.uvprojx, settings and files
target GD32F305_Proj (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F305VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ae64m4 +hex
  BeforeMake: cmd.bat before
  AfterMake: cmd.bat after
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,USE_USB_OTG_FS,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,YX_MPU_SENSOR
  c misc: --C99
  c include: ..\Code_Files\_app\ADC;..\Code_Files\_app\AES128;..\Code_Files\_app\CAN;..\Code_Files\_app\database;..\Code_Files\_app\dataexport;..\Code_Files\_app\driverlogin;..\Code_Files\_app\deliver;..\Code_Files\_app\fat;..\Code_Files\_app\ICcard;..\Code_Files\_app\infrared;..\Code_Files\_app\interface;..\Code_Files\_app\keyboard;..\Code_Files\_app\kline;..\Code_Files\_app\lcd;..\Code_Files\_app\main;..\Code_Files\_app\mileage;..\Code_Files\_app\md5;..\Code_Files\_app\m0_pm;..\Code_Files\_app\printer;..\Code_Files\_app\PhyExUsart;..\Code_Files\_app\phone;..\Code_Files\_app\public;..\Code_Files\_app\pm;..\Code_Files\_app\RFID;..\Code_Files\_app\ring;..\Code_Files\_app\signal;..\Code_Files\_app\update;..\Code_Files\_app\hit;..\Code_Files\_dal\common\h;..\Code_Files\_dal\driver\h;..\Code_Files\_dal\manager\h;..\Code_Files\_dal\usb\core\h;..\Code_Files\_dal\usb\driver\h;..\Code_Files\_dal\usb\MSC\h;..\Code_Files\_dal\usb\user\h;..\Code_Files\_drv\GD32F30x_standard_peripheral\Include;..\Code_Files\_drv\CMSIS;..\Code_Files\_drv\CMSIS\GD\GD32F30x\Include;..\Code_Files\_dal\usb\OTG\h;..\Code_Files\_dal\MPUlib\h;..\Code_Files\_app\exrtc;..\Code_Files\_app\appmain\h;..\Code_Files\_app\balcfg\ioreg\h;..\Code_Files\_app\balcfg\osreg\h;..\Code_Files\_app\balcfg\portreg\h;..\Code_Files\_app\balcfg\ppreg\h;..\Code_Files\_app\can\h;..\Code_Files\_app\com\h;..\Code_Files\_app\database;..\Code_Files\_app\encrypt\h;..\Code_Files\_app\exrtc;..\Code_Files\_app\exuart\h;..\Code_Files\_app\general\h;..\Code_Files\_app\includes;..\Code_Files\_app\interface\h;..\Code_Files\_app\lock\h;..\Code_Files\_app\main;..\Code_Files\_app\power\h;..\Code_Files\_app\public;..\Code_Files\_app\signal\h;..\Code_Files\_bal\comm\h;..\Code_Files\_bal\ppdrv\h;..\Code_Files\_bal\utils\h;..\Code_Files\port;..\Code_Files\_bal\kernel\h;..\Code_Files\_app\hit\h;..\Code_Files\_app\encrypt\h;..\Code_Files\_drv\Template;..\Code_Files\_app\sd2058\h;..\Code_Files\_dal\backtrace;..\Code_Files\_dal\backtrace\Languages;..\Code_Files\_app\uds\h;..\Code_Files\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\110r-m4.sct
  link misc: --diag_suppress=L6329
  group main
    ../Code_Files/_app/main/: appmain.c main.c
  group can
    ../Code_Files/_app/can/c/: yx_can_man.c
  group uds
    ../Code_Files/_app/uds/c/: yx_dtc_drv.c yx_uds_did.c yx_uds_drv.c yx_uds_transfer.c
  group lock
    ../Code_Files/_app/lock/c/: yx_lc_md5.c yx_lock.c YX_md5.c
  group com
    ../Code_Files/_app/com/c/: yx_com_man.c yx_com_recv.c yx_com_send.c
  group database
    ../Code_Files/_app/database/: DataBase.C
  group encrypt
    ../Code_Files/_app/encrypt/c/: libyaxon_stm_nts_se_sdk.lib yx_enc_fun.c yx_encrypt_man.c
  group power
    ../Code_Files/_app/power/c/: yx_power_man.c
  group signal
    ../Code_Files/_app/signal/c/: yx_signal_man.c
  group balcfg
    ../Code_Files/_app/balcfg/ioreg/c/: bal_gpio_cfg.c bal_input_reg.c bal_output_reg.c
    ../Code_Files/_app/balcfg/osreg/c/: os_reg.c
    ../Code_Files/_app/balcfg/portreg/c/: port_constvar.c
  group public
    ../Code_Files/_app/public/: FlashImg.C Public.C RamImage.C s_flash.c systime.c
    ../Code_Files/_bal/ppdrv/c/: bal_pp_drv.c
    ../Code_Files/_app/balcfg/ppreg/c/: bal_pp_reg.c
  group update
    ../Code_Files/_app/update/: APP_update.c
  group hit
    ../Code_Files/_app/hit/c/: yx_hit_man.c
  group comm
    ../Code_Files/_bal/comm/c/: bal_input_drv.c bal_output_drv.c bal_version.c bal_vir_comn_tsk.c
  group general
    ../Code_Files/_app/general/c/: yx_version.c yx_viropttsk.c
  group interfase
    ../Code_Files/_app/interface/c/: yx_configure.c
  group exuart
    ../Code_Files/_app/exuart/c/: yx_exuart_man.c
  group utils
    ../Code_Files/_bal/utils/c/: bal_list.c bal_maplist.c bal_roundbuf.c bal_stream.c bal_tools.c
  group kernel
    ../Code_Files/_bal/kernel/c/: os_diagnose.c
  group port
    ../Code_Files/port/: port_485.c port_adc.c port_can.c port_debug.c port_dm.c port_gpio.c port_msghdl.c port_plat.c port_timer.c port_tsk.c port_uart.c yx_main.c port_gsensor.c port_spi.c port_sflash.c
  group common
    ../Code_Files/_dal/common/c/: list.c roundbuf.c scanner.c stream.c UnicodeTranslate.C
  group driver
    ../Code_Files/_dal/driver/c/: dal_adc.c dal_buzzer.c dal_can.c dal_exti.c dal_flash.c dal_gpio.c dal_hard.c dal_simi2c.c dal_timer.c dal_usart.c default_it.c dal_rtc.c Dal_SIMI2C_2.c dal_infrared.C dal_spi.c dal_gsen_drv.c
  group manager
    ../Code_Files/_dal/manager/c/: debug_print.c man_error.c man_irq.c man_queue.c mmi_resetcnt.c dmemory.c man_timer.c tools.c
  group GD32F30x_standard_peripheral
    ../Code_Files/_drv/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ../Code_Files/_drv/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Code_Files/_drv/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group _lib
    ../Code_Files/lib/: arm_cortexM4lf_math.lib tbox_seed2key.lib libtsc1.lib xichai_ems_seedkey.lib
  group sd2058
    ../Code_Files/_app/sd2058/c/: hal_exrtc_sd2058_drv.c
  group backtrace
    ../Code_Files/_dal/backtrace/: cm_backtrace.c
    ../Code_Files/_dal/backtrace/fault_handler/keil/: cmb_fault.S
