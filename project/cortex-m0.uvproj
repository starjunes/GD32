# Keil uVision project cortex-m0.uvproj, settings and files
target cortex-m0 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: cortex-m0 +hex
  AfterMake: cmd.bat
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F072
  c include: ..\;..\source\hal\STM32F0xx_StdPeriph_Driver\inc;..\source\hal\CMSIS\Include;..\source\hal\CMSIS\ST\STM32F0xx\Include;..\source\hal\main\h;..\source\hal\CMSIS\ST\STM32F0xx\Include;..\source\hal\kernal\h;..\source\hal\toolbox\h;..\source\hal\debug\h;..\source\hal\driver\h;..\source\dal\device\h;..\source\dal\at\h;..\source\app\include;..\source\app\mmi\h;..\source\app\common\h;..\source\app\link\h
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\cortex-m0.sct
  group app
    ../source/app/common/c/: yx_app_tsk.c yx_version.c yx_resetrecord.c yx_sleep.c yx_bootmain.c yx_sm_cmd.c
  group app_link
    ../source/app/link/c/: yx_jt1_trecv.c yx_jt1_tsend.c yx_jt1_tlink.c yx_jt2_tsend.c yx_jt2_tlink.c yx_jt2_trecv.c yx_jt_linkman.c yx_protocol_send.c yx_protocol_recv.c
  group app_mmi
    ../source/app/mmi/c/: yx_mmi_can.c yx_mmi_common.c yx_mmi_gps.c yx_mmi_sensor.c yx_mmi_tr.c yx_mmi_power.c yx_mmi_download.c yx_mmi_uartext.c yx_mmi_drv.c yx_mmi_recv.c yx_mmi_send.c yx_mmi_com.c
  group dal_device
    ../source/dal/device/c/: dal_gpio_cfg.c dal_ic_drv.c dal_input_drv.c dal_input_reg.c dal_output_drv.c dal_output_reg.c dal_pulse_drv.c yx_dal_tsk.c dal_pp_reg.c dal_pp_drv.c dal_hit_drv.c
  group dal_at
    ../source/dal/at/c/: at_com.c at_drv.c at_recv.c at_send.c at_core.c at_other.c at_pdu.c at_pdu_cdma.c at_power.c at_cmd_common.c at_cmd_phone.c at_cmd_sms.c at_cmd_tcpip.c at_urc_sms.c at_urc_tcpip.c at_urc_phone.c at_urc_common.c at_q_phone.c at_q_tcpip.c at_q_sms.c at_q_set.c at_socket_drv.c at_gprs_drv.c
  group hal_debug
    ../source/hal/debug/c/: yx_debug.c
  group hal_driver
    ../source/hal/driver/c/: st_uart_drv.c st_uart_irq.c st_uart_reg.c st_irq_drv.c st_irq_def.c st_gpio_reg.c st_gpio_drv.c st_i2c_reg.c st_i2c_simu.c st_exti_drv.c st_rtc_drv.c st_adc_reg.c st_adc_drv.c hal_flash_drv.c hal_sflash_drv.c hal_hit_drv.c hal_can_reg.c hal_can_drv.c hal_ic_drv.c
  group hal_toolbox
    ../source/hal/toolbox/c/: yx_dym_cfg.c yx_list.c yx_loopbuf.c yx_misc.c yx_dym_drv.c yx_stream.c yx_heapmem.c
  group hal_kernal
    ../source/hal/kernal/c/: os_errman.c os_qmsg.c os_reg.c os_timer.c os_bsp.c
  group hal_main
    ../source/hal/main/c/: main.c stm32f0_discovery.c yx_hal_tsk.c
  group hal_cmsis
    ../source/hal/CMSIS/ST/STM32F0xx/Source/: startup_stm32f0xx.s stm32f0xx_it.c system_stm32f0xx.c
  group hal_lib
    ../source/hal/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_can.c
